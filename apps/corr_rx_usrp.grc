<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>corr_rx_usrp</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>PRF</value></param>
<param><key>value</key><value>samp_rate/len_pulse/M</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>degree</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>gps_status</value></param>
<param><key>block_id</key><value>uhd_usrp_source_0</value></param>
<param><key>function_args</key><value>'"gps_locked"'</value></param>
<param><key>function_name</key><value>get_mboard_sensor</value></param>
<param><key>value</key><value>"not yet evalueated"</value></param>
<param><key>poll_rate</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_pulse</value></param>
<param><key>value</key><value>2**degree-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_meas</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>printer</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>sys.stdout.write(str(gps_status)+ '\n')</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100e6/5</value></param>
</block>
<block>
<key>channelsounder_avg_m_over_n_cc</key>
<param><key>id</key><value>channelsounder_avg_m_over_n_cc_0</value></param>
<param><key>m</key><value>M</value></param>
<param><key>win_size</key><value>len_pulse</value></param>
</block>
<block>
<key>channelsounder_mls_corr</key>
<param><key>id</key><value>channelsounder_mls_corr_0</value></param>
<param><key>degree</key><value>degree</value></param>
<param><key>mask</key><value>0</value></param>
<param><key>seed</key><value>1</value></param>
</block>
<block>
<key>cs_sink_c</key>
<param><key>id</key><value>cs_sink_c_0</value></param>
<param><key>ntau</key><value>len_pulse</value></param>
<param><key>nt</key><value>n_meas</value></param>
<param><key>prf</key><value>PRF</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>900e6</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>3</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.5</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>otw</key><value>sc8</value></param>
</block>
<connection><source_block_id>channelsounder_avg_m_over_n_cc_0</source_block_id><sink_block_id>channelsounder_mls_corr_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channelsounder_mls_corr_0</source_block_id><sink_block_id>cs_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>channelsounder_avg_m_over_n_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
